# IAR project demo.ewp, settings and files
configuration Debug (ARM)
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: include; ..\drivers\inc
  ILINK.IlinkIcfFile: link.icf
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group (top)
    src/: main.c
  group App
    src/: app.c
  group App/Drivers
    src/: drv.c
